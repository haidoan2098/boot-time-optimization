FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-bb.org:"
SRC_URI += "file://bootdelay.cfg"
